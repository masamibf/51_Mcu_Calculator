# Keil uVision project 课程设计(计算器).uvproj, settings and files
target Calculate (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: 课程设计(计算器) +hex
  c flags: Optimize=8 SizeSpeed=1
  group STARTUP
    ./STARTUP/: STARTUP.A51
  group App
    ./App/: main.c
  group Kernel
    ./Kernel/: Calculate.c StrPro.c
  group Driver
    ./Driver/: 24c02.c 1602.c Buzzer.c key.c key2.c
